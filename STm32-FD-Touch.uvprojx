# Keil uVision project STm32-FD-Touch.uvprojx, settings and files
target STM32-FD-TOUCH (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32-fd-touch +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\FWlib\inc;.\user;.\CM3;.\TFT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./startup/: startup_stm32f10x_hd.s
  group User
    ./user/: main.c gt9147.c gti2c.c stm32f10x_it.c stm32f10x_tim.c Tim.c SD_Card.c diskio.c ff.c tjpgd.c sdio_sdcard.c MCP.c AD.c
    ./FWlib/SRC/: stm32f10x_dma.c stm32f10x_sdio.c
  group FWlib
    ./FWlib/SRC/: stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_adc.c
  group TFT
    ./TFT/: fsmc_sram.c LCDDRV.c
  group CM3
    ./CM3/: core_cm3.c system_stm32f10x.c
  group readme
    ./user/: readme.txt
  group mySystem
    ./: mySystem.c
